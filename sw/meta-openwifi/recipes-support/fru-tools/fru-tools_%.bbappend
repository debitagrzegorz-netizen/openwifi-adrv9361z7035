# SPDX-License-Identifier: MIT
# meta-adi follows fru_tools main when the build has a network. That tree
# replaced license.txt, so the recipe checksum no longer matches. The recipe
# already names this revision for offline builds. Pin it.
SRCREV = "e98eae11db567c8c8b8076998a68ac8467e52646"
